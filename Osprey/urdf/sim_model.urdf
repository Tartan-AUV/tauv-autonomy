Commit message: real pid tuning

File: Osprey/urdf/sim_model.urdf (robot description, URDF)
Before this commit: robot osprey, 17 links, 16 joints
Joints:
- joint dvl_joint: origin xyz=0 -0.140832 0.0100375 rpy=0 0 0 -> xyz=0 -0.140832 0.0100375 rpy=0 3.14159265 0
